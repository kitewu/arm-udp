# Keil uVision project TFTP_Test.uvproj, settings and files
target TFTP_Test IN RAM (ARM-ADS)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: TFTP_Test
  c flags: Optim=1
  c include: ..\Common\Inc;.\INC;.\INC\tftp
  asm define: ENABLEMMU
  memory RVCT1: ROM 0x30000000 size 0x30000
  memory RVCT6: RAM 0x30030000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group Startup
    ./: S3C2410A.s
  group Source
    ./Source/: main.c rtc_test.c
    ./Source/tftp/: arp.c dm9000dbg.c eth.c icmp.c ip.c skbuff.c tftp.c tftpmain.c tftpput.c udp.c
  group Common
    ../common/src/: 2410lib.c sys_init.c
  group IniFile
    ./: SDRAM.ini
  group ReadMe
    ./: readme.txt
target TFTP_Test IN FLASH (ARM-ADS)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: TFTP_Test +hex
  c flags: Optim=1
  c include: ..\Common\Inc;.\Inc;.\Inc\tftp
  memory RVCT1: ROM 0x0 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x4000000
  memory RVCT9: RAM 0x40000000 size 0x1000
